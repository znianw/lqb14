# Keil uVision project lqb14.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: lqb14
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver\inc;.\device\inc;.\user
  group device
    ./: STARTUP.A51
    ./device/src/: ds18b20.c hc573.c key.c led.c pcf8591.c smg.c timer.c
  group driver
    ./driver/src/: delay.c i2c.c
  group user
    ./user/: main.c
